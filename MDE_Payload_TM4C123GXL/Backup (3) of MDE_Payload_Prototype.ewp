# IAR project Backup (3) of MDE_Payload_Prototype.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: MDE_Payload_Prototype.bin
  ILINK.IlinkOutputFile: MDE_Payload_Prototype.out
  ILINK.IlinkIcfFile: MDE_Payload_Prototype.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: Access_Tools.c Access_Tools.h CY15B104Q.c CY15B104Q.h IS62WVS5128GBLL.c IS62WVS5128GBLL.h M95M02.c M95M02.h MDE_Payload_Prototype.c MDE_Payload_Prototype.h MR25H40.c MR25H40.h S25FL256LA.c S25FL256LA.h startup_ewarm.c
